# IAR project littlevgl_widgets_test.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; LV_CONF_INCLUDE_SIMPLE=1; LV_EX_CONF_INCLUDE_SIMPLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; VG_RESOLVE_ENGINE=0; VG_PE_COLOR_KEY=0; VG_IM_INDEX_FORMAT=0; VG_AYUV_INPUT_OUTPUT=0; VG_DOUBLE_IMAGE=0; VG_RECTANGLE_STRIP_MODE=0; VG_MMU=0; VG_IM_FILTER=0; VG_IM_YUV_PACKET=1; VG_IM_YUV_PLANAR=0; VG_PE_YUV_PACKET=1; VG_TARGET_TILED=1; VG_COMMAND_CALL=1; VG_SHARE_BUFFER_IM_16K=0; VG_OFFLINE_MODE=0; VG_RESOLUTION_2880=0; VG_PE_PREMULTIPLY=0; VG_POST_CONVERTER=0; VG_PRE_CONVERTER=0; VG_RENDER_BY_MESH=0; VG_TARGET_FAST_CLEAR=0; VG_BUFFER_NUMBER_OF_TARGET=0; VG_VIDEO_CLEAR_CONTROL=0; VG_VIDEO_CONTROL=0; VGLITE_TST_FIRMWARE=0; VG_LITE_SYS_GPU_CTRL=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; source; CMSIS; component/lists; component/serial_manager; component/uart; device; drivers; evkmimxrt1170/littlevgl_examples/littlevgl_demo_widgets/cm7; freertos/freertos_kernel/include; freertos/freertos_kernel/portable/IAR/ARM_CM4F; littlevgl; littlevgl/lv_examples; littlevgl/lv_examples/src/lv_demo_widgets; littlevgl/lv_examples/src/lv_demo_music; littlevgl/lv_examples/src/lv_demo_benchmark; littlevgl/lv_examples/src/lv_demo_keypad_encoder; littlevgl/lvgl; littlevgl/lvgl/src; touchpanel; utilities; vglite/VGLite/rtos; vglite/VGLiteKernel; vglite/VGLiteKernel/rtos; vglite/font; vglite/font/mcufont/decoder; vglite/inc; video; xip
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: source
  ILINK.IlinkOutputFile: littlevgl_widgets_test.out
  ILINK.IlinkIcfFile: MIMXRT1176/iar/MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; LV_CONF_INCLUDE_SIMPLE=1; LV_EX_CONF_INCLUDE_SIMPLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; VG_RESOLVE_ENGINE=0; VG_PE_COLOR_KEY=0; VG_IM_INDEX_FORMAT=0; VG_AYUV_INPUT_OUTPUT=0; VG_DOUBLE_IMAGE=0; VG_RECTANGLE_STRIP_MODE=0; VG_MMU=0; VG_IM_FILTER=0; VG_IM_YUV_PACKET=1; VG_IM_YUV_PLANAR=0; VG_PE_YUV_PACKET=1; VG_TARGET_TILED=1; VG_COMMAND_CALL=1; VG_SHARE_BUFFER_IM_16K=0; VG_OFFLINE_MODE=0; VG_RESOLUTION_2880=0; VG_PE_PREMULTIPLY=0; VG_POST_CONVERTER=0; VG_PRE_CONVERTER=0; VG_RENDER_BY_MESH=0; VG_TARGET_FAST_CLEAR=0; VG_BUFFER_NUMBER_OF_TARGET=0; VG_VIDEO_CLEAR_CONTROL=0; VG_VIDEO_CONTROL=0; VGLITE_TST_FIRMWARE=0; VG_LITE_SYS_GPU_CTRL=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: board; source; CMSIS; component/lists; component/serial_manager; component/uart; device; drivers; evkmimxrt1170/littlevgl_examples/littlevgl_demo_widgets/cm7; freertos/freertos_kernel/include; freertos/freertos_kernel/portable/IAR/ARM_CM4F; littlevgl; littlevgl/lv_examples; littlevgl/lv_examples/src/lv_demo_widgets; littlevgl/lvgl; littlevgl/lvgl/src; touchpanel; utilities; vglite/VGLite/rtos; vglite/VGLiteKernel; vglite/VGLiteKernel/rtos; vglite/font; vglite/font/mcufont/decoder; vglite/inc; video; xip
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h display_support.c display_support.h littlevgl_support.c littlevgl_support.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    component/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lcdifv2.c fsl_lcdifv2.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_memory.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_pmu.c fsl_pmu.h fsl_pxp.c fsl_pxp.h fsl_soc_mipi_csi2rx.c fsl_soc_mipi_csi2rx.h fsl_soc_src.c fsl_soc_src.h
  group evkmimxrt1170
    evkmimxrt1170/: evkmimxrt1170_connect_cm4_cm7side.jlinkscript evkmimxrt1170_connect_cm7.mac
  group freertos/freertos_kernel
    freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/freertos_kernel/portable
    freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group littlevgl
    littlevgl/: ChangeLogKSDK.txt lv_demo.h
  group littlevgl/lv_examples
    littlevgl/lv_examples/: lv_demo.h lv_examples.h
  group littlevgl/lv_examples/src/lv_demo_benchmark
    littlevgl/lv_examples/src/lv_demo_benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
    littlevgl/lv_examples/src/lv_demo_benchmark/: lv_demo_benchmark.c lv_demo_benchmark.h
  group littlevgl/lv_examples/src/lv_demo_keypad_encoder
    littlevgl/lv_examples/src/lv_demo_keypad_encoder/: lv_demo_keypad_encoder.c lv_demo_keypad_encoder.h
  group littlevgl/lv_examples/src/lv_demo_music
    littlevgl/lv_examples/src/lv_demo_music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c spectrum_1.h spectrum_2.h spectrum_3.h
    littlevgl/lv_examples/src/lv_demo_music/: lv_demo_music.c lv_demo_music.h lv_demo_music_list.c lv_demo_music_list.h lv_demo_music_main.c lv_demo_music_main.h
  group littlevgl/lv_examples/src/lv_demo_test
    littlevgl/lv_examples/src/lv_demo_test/: lv_examples.h
  group littlevgl/lv_examples/src/lv_demo_test/get_started
    littlevgl/lv_examples/src/lv_demo_test/get_started/: lv_example_get_started.h lv_example_get_started_1.c lv_example_get_started_2.c lv_example_get_started_3.c
  group littlevgl/lv_examples/src/lv_demo_test/style
    littlevgl/lv_examples/src/lv_demo_test/styles/: lv_example_style.h lv_example_style_1.c lv_example_style_10.c lv_example_style_11.c lv_example_style_12.c lv_example_style_13.c lv_example_style_14.c lv_example_style_2.c lv_example_style_3.c lv_example_style_4.c lv_example_style_5.c lv_example_style_6.c lv_example_style_7.c lv_example_style_8.c lv_example_style_9.c
  group littlevgl/lv_examples/src/lv_demo_widgets
    littlevgl/lv_examples/src/lv_demo_widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    littlevgl/lv_examples/src/lv_demo_widgets/: lv_demo_widgets.c lv_demo_widgets.h
  group littlevgl/lvgl
    littlevgl/lvgl/: LICENCE.txt lvgl.h README.md
  group littlevgl/lvgl/docs
    littlevgl/lvgl/docs/: CODING_STYLE.md CONTRIBUTING.md ROADMAP.md
  group littlevgl/lvgl/examples/porting
    littlevgl/lvgl/examples/porting/: lv_port_disp_template.c lv_port_disp_template.h lv_port_fs_template.c lv_port_fs_template.h lv_port_indev_template.c lv_port_indev_template.h
  group littlevgl/lvgl/src
    littlevgl/lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h
  group littlevgl/lvgl/src/core
    littlevgl/lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group littlevgl/lvgl/src/draw
    littlevgl/lvgl/src/draw/: lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_blend.c lv_draw_blend.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group littlevgl/lvgl/src/extra
    littlevgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
    littlevgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
    littlevgl/lvgl/src/extra/widgets/chart/: lv_chart.c lv_chart.h
    littlevgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
    littlevgl/lvgl/src/extra/: lv_extra.c lv_extra.h
    littlevgl/lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.h
    littlevgl/lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.h
    littlevgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
    littlevgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c lv_keyboard.h
    littlevgl/lvgl/src/extra/layouts/: lv_layouts.h
    littlevgl/lvgl/src/extra/widgets/led/: lv_led.c lv_led.h
    littlevgl/lvgl/src/extra/libs/: lv_libs.h
    littlevgl/lvgl/src/extra/widgets/list/: lv_list.c lv_list.h
    littlevgl/lvgl/src/extra/widgets/meter/: lv_meter.c lv_meter.h
    littlevgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
    littlevgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.h
    littlevgl/lvgl/src/extra/widgets/span/: lv_span.c lv_span.h
    littlevgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
    littlevgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
    littlevgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
    littlevgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
    littlevgl/lvgl/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
    littlevgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
    littlevgl/lvgl/src/extra/themes/: lv_themes.h
    littlevgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
    littlevgl/lvgl/src/extra/widgets/: lv_widgets.h
    littlevgl/lvgl/src/extra/widgets/win/: lv_win.c lv_win.h
  group littlevgl/lvgl/src/font
    littlevgl/lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group littlevgl/lvgl/src/gpu
    littlevgl/lvgl/src/gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h lv_gpu_nxp_vglite.c lv_gpu_nxp_vglite.h lv_gpu_sdl.c lv_gpu_sdl.h lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
  group littlevgl/lvgl/src/hal
    littlevgl/lvgl/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group littlevgl/lvgl/src/misc
    littlevgl/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group littlevgl/lvgl/src/widgets
    littlevgl/lvgl/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
  group MIMXRT1176/iar
    MIMXRT1176/iar/: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  group source
    source/: FreeRTOSConfig.h littlevgl_demo_widgets.c lv_conf.h lv_ex_conf.h
  group startup
    startup/: startup_MIMXRT1176_cm7.s
  group touchpanel
    touchpanel/: fsl_gt911.c fsl_gt911.h
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group vglite
    vglite/: ChangeLogKSDK.txt LICENSE.txt
  group vglite/font
    vglite/font/: buf_reader.c buf_reader.h fonts.h rle_font_read.c vft_debug.c vft_debug.h vft_draw.c vft_draw.h vg_lite_text.c
  group vglite/font/mcufont
    vglite/font/mcufont/: LICENSE
  group vglite/font/mcufont/decoder
    vglite/font/mcufont/decoder/: mcufont.h mf_bwfont.c mf_bwfont.h mf_config.h mf_encoding.c mf_encoding.h mf_font.c mf_font.h mf_justify.c mf_justify.h mf_kerning.c mf_kerning.h mf_rlefont.c mf_rlefont.h mf_scaledfont.c mf_scaledfont.h mf_wordwrap.c mf_wordwrap.h
  group vglite/inc
    vglite/inc/: vg_lite.h vg_lite_hal.h vg_lite_text.h
  group vglite/VGLite
    vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c
  group vglite/VGLite/rtos
    vglite/VGLite/rtos/: vg_lite_os.c vg_lite_os.h
  group vglite/VGLiteKernel
    vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h
  group vglite/VGLiteKernel/rtos
    vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group video
    video/: fsl_dc_fb.h fsl_dc_fb_elcdif.c fsl_dc_fb_elcdif.h fsl_dc_fb_lcdifv2.c fsl_dc_fb_lcdifv2.h fsl_display.h fsl_mipi_dsi_cmd.c fsl_mipi_dsi_cmd.h fsl_rm68191.c fsl_rm68191.h fsl_rm68200.c fsl_rm68200.h fsl_video_common.c fsl_video_common.h
  group xip
    xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
