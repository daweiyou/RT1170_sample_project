<?xml version="1.0" encoding="ISO-8859-1" standalone="no"?>
<workspace>
    
  <batchBuild>
        
    <batchDefinition>
            
      <name>all</name>
            
      <member>
                
        <project>littlevgl_widgets_test</project>
                
        <configuration>flexspi_nor_sdram_debug</configuration>
              
      </member>
            
      <member>
                
        <project>littlevgl_widgets_test</project>
                
        <configuration>flexspi_nor_sdram_release</configuration>
              
      </member>
          
    </batchDefinition>
        
    <batchDefinition>
            
      <name>flexspi_nor_sdram_debug</name>
            
      <member>
                
        <project>littlevgl_widgets_test</project>
                
        <configuration>flexspi_nor_sdram_debug</configuration>
              
      </member>
          
    </batchDefinition>
        
    <batchDefinition>
            
      <name>flexspi_nor_sdram_release</name>
            
      <member>
                
        <project>littlevgl_widgets_test</project>
                
        <configuration>flexspi_nor_sdram_release</configuration>
              
      </member>
          
    </batchDefinition>
      
  </batchBuild>
    
  <project>
        
    <path>$WS_DIR$/littlevgl_widgets_test.ewp</path>
      
  </project>
  
</workspace>
